<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IWDG_SystemMonitor.ewp</path>
    </project>
    <batchBuild />
</workspace>
