<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PWR_DeepStop_EXTI_Wakeup.ewp</path>
    </project>
    <batchBuild />
</workspace>
