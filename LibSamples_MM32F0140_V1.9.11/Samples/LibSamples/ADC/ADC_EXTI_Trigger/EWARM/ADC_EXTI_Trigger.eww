<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_EXTI_Trigger.ewp</path>
    </project>
    <batchBuild />
</workspace>
