<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_AnyChannel_OneCycleScan_DMA_Interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
