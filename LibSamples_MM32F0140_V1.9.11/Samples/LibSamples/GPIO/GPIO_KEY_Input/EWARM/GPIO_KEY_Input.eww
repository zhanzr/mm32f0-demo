<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GPIO_KEY_Input.ewp</path>
    </project>
    <batchBuild />
</workspace>
