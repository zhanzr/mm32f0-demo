<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FLASH_OptionByte_Erase_Program.ewp</path>
    </project>
    <batchBuild />
</workspace>
