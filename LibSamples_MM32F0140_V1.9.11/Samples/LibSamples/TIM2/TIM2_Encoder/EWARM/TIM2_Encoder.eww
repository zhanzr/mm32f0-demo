<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM2_Encoder.ewp</path>
    </project>
    <batchBuild />
</workspace>
